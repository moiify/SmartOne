# Keil uVision project Car.uvprojx, settings and files
target Car (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Fuction\INC;..\Core&Library\inc;..\Core&Library
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Project
    ./: main.c
  group Fuction
    ../Fuction/SRC/: delay.c key.c led.c Pwm.c sys.c timer.c Control.c Ultrasonic.c usart.c
  group Core&Library
    ../Core&Library/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../Core&Library/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
